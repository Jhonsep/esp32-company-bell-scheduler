## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y
CONFIG_LWIP_SNTP_UPDATE_DELAY=21600000
CONFIG_HTTPD_MAX_REQ_HDR_LEN=1024
```
